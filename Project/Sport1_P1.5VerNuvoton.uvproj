# Keil uVision project Sport1_P1.5VerNuvoton.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: Sport1_P1.5VerNuvoton +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include
  group Source
    ./Source/: main.c
  group Common
    ../Common/: Common.c Delay.c
  group Include
    ../Include/: Common.h Delay.h Function_Define.h N76E003.h SFR_Macro.h
  group Startup
    ../Startup/: STARTUP.A51
